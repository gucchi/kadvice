## Kconfig
```kconfig
config SECURITY_SECURITYCUBE
	bool "Security Cube Support"
	depends on SECURITY
	default n
	help
	  Security Cube support on.
```
